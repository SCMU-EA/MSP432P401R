# Keil uVision project MSP432.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSP432
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil
  c include: ..\Library;..\Basic\Delay;..\Basic;..\Hardware\LED;..\Library;..\Hardware\OLED;..\Basic\RTC;..\Hardware\Button;..\Basic\Usart;..\Basic\STM32F1xx_VisualTFT;..\Basic\TimA;..\Basic\SystemInit;..\Hardware\AD9959
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ../User/: main.c
  group Basic
    ../Basic/Delay/: delay.c
    ../Basic/Usart/: usart.c
    ../Basic/TimA/: timA.c
    ../Basic/SystemInit/: sysinit.c
  group Hardware
    ../Hardware/OLED/: oled.c
    ../Hardware/LED/: led.c
    ../Hardware/AD9959/: AD9959.c
  group Library
    ../Library/: msp432p4xx_driverlib.lib
  group TFT
    ../Basic/STM32F1xx_VisualTFT/: cmd_process.c cmd_queue.c hmi_driver.c hmi_user_uart.c
software components: CMSIS:CORE 5.1.1, Device:Startup 3.2.2
